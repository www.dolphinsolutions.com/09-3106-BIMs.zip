Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-02-16T15:24:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Feb 16 15:24:37 2017* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{39B81B9F-D95F-4C00-9DC3-DCCF3E213D07}\ifc* Database version: 5507* Database creation date: Thu Feb 16 15:24:37 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Feb 16 15:24:37 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Feb 16 15:24:37 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: StainlessSteel, NBS_FCFrostLtd_PaperTowelDispensers_DropdownFlatBottomBehindMirrorPaperTowelDispenser:StainlessSteel:304039
In: Level 0
Type - ElementType: StainlessSteel; Classification: Pr_40_70_22_62 (Uniclass2015); Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_FCFrostLtd_PaperTowelDispensers_DropdownFlatBottomBehindMirrorPaperTowelDispenser; ManufacturerName: FC Frost Ltd; ManufacturerURL: www.fcfrost.com; NBSCertification: www.nationalbimlibrary.com/cert/g031cjd3; NBSDescription: Paper towel dispensers; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/344; NBSTypeID: n/a; ProductInformation: www.fcfrost.com/09.3106.html; Revision: n/a; Uniclass2015Code: Pr_40_70_22_62; Uniclass2015Title: Paper towel dispensers; Uniclass2015Version: ProdUcts v1.5; Version: 1
Type - NBS_Data - EnvironmentalProductDeclaration: n/a; Form: Wall mounted; TowelsTowelType: n/a; TowelsWidth: n/a; Operation: Pull out; IntegralAccessories: n/a; CapacityPaperTowels: C fold: 275 (225-240 x 90-100 mm), Interleave: 400 (215-240 x 80-100 mm); NetWeight: 4.3 kg; RecommendedMountingHeight: From underside of unit to finished floor level: Male: 1400 mm; Spares: Contact FC Frost for spares requirements: service@fcfrost.com
Type - Pset_FurnitureTypeCommon - Description: Recessed flat, behind mirror, drop-down loading, satin finish stainless steel paper towel dispenser. Holds 200 ‘C’ fold or 300 interleave paper towels; Style: n/a; NominalHeight: 380 mm; NominalDepth: 112 mm; MainColor: n/a
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: TOWELDISPENSER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Specialty Equipment; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Behind mirror installation flat bottom drop down paper towel dispenser. Vertically brushed satin finish stainless steel with lockable drop down mechanism for easy loading; Finish: Satin; Grade: n/a; Manufacturer: info@fcfrost.com; Material: 0.9 mm stainless steel grade 1.4301 (304); ModelNumber: 9.3106; ModelReference: Paper Towel Dispenser - Behind Mirror Dropdown; Name: PaperTowelDispensers_DropdownFlatBottomBehindMirrorPaperTowelDispenser_FCFrostLtd; NominalWidth: 293 mm; Shape: n/a; Size: 112 x 293 x 380 mm; SustainabilityPerformance: n/a; WarrantyDescription: This product is covered by a 12 month warranty from the date of purchase to be free from defects if installed and maintained in accordance with the products instructions. FC Frost will replace or repair (as appropriate) free of charge any product with a proven manufacturing defect if reported within the warranty period; WarrantyDurationLabor: n/a; WarrantyDurationParts: year; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyGuarantorParts: n/a
